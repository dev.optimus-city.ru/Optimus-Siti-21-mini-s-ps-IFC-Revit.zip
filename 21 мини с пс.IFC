Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: IFC4
File name: 21 мини с пс.IFC
Time: 2025-11-26T08:06:52
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 21.stp[1000]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1001]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1002]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1003]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1004]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1005]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1006]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1007]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1008]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1009]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[100]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1010]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1011]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1012]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1013]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1014]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1015]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1016]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1017]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1018]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1019]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[101]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1020]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1021]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1022]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1023]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1024]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1025]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1026]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1027]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1028]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1029]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[102]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1030]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1031]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1032]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1033]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1034]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1035]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1036]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1037]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1038]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1039]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[103]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1040]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1041]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1042]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1043]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1044]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1045]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1046]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1047]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1048]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1049]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[104]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1050]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1051]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1052]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1053]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1054]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1055]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1056]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1057]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1058]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1059]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[105]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1060]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1061]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1062]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1063]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1064]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1065]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1066]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1067]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1068]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1069]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[106]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1070]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1071]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1072]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1073]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1074]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1075]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1076]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1077]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1078]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1079]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[107]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1080]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1081]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1082]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1083]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1084]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1085]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1086]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1087]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1088]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1089]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[108]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1090]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1091]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1092]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1093]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1094]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1095]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1096]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1097]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1098]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1099]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[109]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[10]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1100]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1101]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1102]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1103]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1104]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1105]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1106]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1107]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1108]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1109]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[110]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1110]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1111]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1112]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1113]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1114]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1115]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1116]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1117]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1118]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1119]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[111]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1120]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1121]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1122]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1123]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1124]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1125]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1126]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1127]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1128]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1129]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[112]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1130]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1131]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1132]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1133]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1134]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1135]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1136]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1137]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1138]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1139]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[113]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1140]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1141]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1142]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1143]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1144]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1145]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1146]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1147]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1148]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1149]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[114]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1150]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1151]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1152]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1153]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1154]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1155]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1156]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1157]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1158]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1159]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[115]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1160]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1161]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1162]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1163]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1164]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1165]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1166]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1167]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1168]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1169]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[116]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1170]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1171]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1172]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1173]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1174]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1175]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1176]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1177]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1178]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1179]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[117]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1180]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1181]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1182]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1183]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1184]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1185]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1186]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1187]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1188]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1189]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[118]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1190]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1191]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1192]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1193]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1194]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1195]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1196]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1197]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1198]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1199]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[119]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[11]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1200]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1201]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1202]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1203]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1204]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1205]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1206]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1207]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1208]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1209]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[120]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1210]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1211]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1212]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1213]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1214]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1215]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1216]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1217]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1218]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1219]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[121]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1220]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1221]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1222]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1223]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1224]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1225]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1226]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1227]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1228]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1229]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[122]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1230]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1231]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1232]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1233]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1234]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1235]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1236]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1237]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[123]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[124]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[125]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[126]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[127]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[128]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[129]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[12]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[130]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[131]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[132]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[133]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[134]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[135]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[136]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[137]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[138]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[139]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[13]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[140]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[141]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[142]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[143]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[144]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[145]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[146]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[147]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[148]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[149]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[14]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[150]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[151]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[152]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[153]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[154]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[155]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[156]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[157]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[158]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[159]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[15]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[160]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[161]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[162]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[163]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[164]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[165]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[166]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[167]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[168]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[169]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[16]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[170]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[171]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[172]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[173]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[174]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[175]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[176]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[177]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[178]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[179]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[17]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[180]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[181]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[182]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[183]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[184]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[185]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[186]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[187]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[188]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[189]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[18]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[190]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[191]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[192]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[193]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[194]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[195]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[196]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[197]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[198]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[199]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[19]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[200]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[201]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[202]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[203]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[204]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[205]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[206]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[207]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[208]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[209]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[20]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[210]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[211]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[212]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[213]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[214]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[215]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[216]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[217]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[218]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[219]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[21]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[220]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[221]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[222]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[223]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[224]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[225]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[226]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[227]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[228]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[229]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[22]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[230]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[231]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[232]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[233]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[234]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[235]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[236]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[237]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[238]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[239]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[23]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[240]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[241]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[242]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[243]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[244]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[245]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[246]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[247]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[248]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[249]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[24]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[250]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[251]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[252]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[253]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[254]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[255]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[256]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[257]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[258]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[259]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[25]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[260]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[261]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[262]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[263]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[264]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[265]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[266]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[267]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[268]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[269]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[26]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[270]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[271]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[272]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[273]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[274]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[275]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[276]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[277]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[278]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[279]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[27]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[280]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[281]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[282]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[283]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[284]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[285]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[286]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[287]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[288]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[289]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[28]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[290]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[291]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[292]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[293]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[294]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[295]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[296]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[297]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[298]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[299]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[29]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[300]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[301]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[302]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[303]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[304]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[305]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[306]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[307]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[308]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[309]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[30]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[310]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[311]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[312]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[313]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[314]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[315]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[316]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[317]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[318]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[319]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[31]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[320]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[321]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[322]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[323]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[324]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[325]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[326]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[327]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[328]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[329]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[32]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[330]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[331]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[332]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[333]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[334]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[335]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[336]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[337]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[338]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[339]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[33]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[340]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[341]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[342]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[343]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[344]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[345]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[346]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[347]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[348]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[349]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[34]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[350]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[351]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[352]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[353]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[354]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[355]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[356]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[357]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[358]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[359]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[35]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[360]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[361]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[362]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[363]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[364]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[365]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[366]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[367]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[368]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[369]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[36]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[370]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[371]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[372]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[373]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[374]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[375]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[376]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[377]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[378]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[379]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[37]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[380]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[381]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[382]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[383]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[384]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[385]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[386]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[387]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[388]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[389]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[38]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[390]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[391]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[392]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[393]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[394]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[395]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[396]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[397]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[398]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[399]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[39]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[400]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[401]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[402]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[403]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[404]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[405]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[406]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[407]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[408]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[409]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[40]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[410]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[411]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[412]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[413]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[414]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[415]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[416]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[417]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[418]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[419]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[41]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[420]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[421]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[422]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[423]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[424]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[425]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[426]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[427]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[428]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[429]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[42]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[430]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[431]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[432]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[433]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[434]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[435]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[436]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[437]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[438]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[439]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[43]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[440]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[441]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[442]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[443]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[444]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[445]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[446]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[447]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[448]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[449]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[44]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[450]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[451]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[452]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[453]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[454]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[455]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[456]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[457]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[458]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[459]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[45]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[460]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[461]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[462]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[463]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[464]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[465]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[466]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[467]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[468]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[469]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[46]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[470]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[471]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[472]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[473]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[474]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[475]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[476]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[477]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[478]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[479]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[47]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[480]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[481]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[482]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[483]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[484]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[485]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[486]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[487]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[488]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[489]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[48]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[490]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[491]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[492]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[493]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[494]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[495]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[496]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[497]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[498]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[499]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[49]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[500]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[501]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[502]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[503]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[504]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[505]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[506]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[507]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[508]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[509]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[50]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[510]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[511]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[512]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[513]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[514]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[515]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[516]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[517]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[518]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[519]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[51]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[520]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[521]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[522]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[523]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[524]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[525]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[526]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[527]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[528]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[529]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[52]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[530]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[531]
In: Default Storey
PredefinedType: ELEMENT
