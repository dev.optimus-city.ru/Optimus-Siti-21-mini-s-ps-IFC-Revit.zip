Properties of the parts of a building model (IFC4), part 2 of 2

# IfcBuildingElementProxy: 21.stp[532]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[533]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[534]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[535]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[536]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[537]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[538]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[539]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[53]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[540]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[541]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[542]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[543]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[544]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[545]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[546]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[547]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[548]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[549]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[54]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[550]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[551]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[552]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[553]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[554]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[555]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[556]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[557]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[558]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[559]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[55]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[560]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[561]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[562]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[563]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[564]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[565]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[566]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[567]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[568]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[569]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[56]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[570]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[571]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[572]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[573]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[574]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[575]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[576]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[577]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[578]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[579]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[57]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[580]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[581]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[582]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[583]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[584]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[585]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[586]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[587]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[588]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[589]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[58]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[590]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[591]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[592]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[593]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[594]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[595]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[596]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[597]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[598]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[599]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[59]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[600]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[601]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[602]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[603]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[604]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[605]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[606]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[607]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[608]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[609]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[60]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[610]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[611]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[612]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[613]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[614]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[615]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[616]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[617]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[618]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[619]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[61]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[620]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[621]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[622]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[623]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[624]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[625]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[626]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[627]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[628]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[629]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[62]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[630]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[631]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[632]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[633]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[634]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[635]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[636]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[637]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[638]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[639]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[63]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[640]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[641]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[642]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[643]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[644]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[645]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[646]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[647]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[648]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[649]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[64]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[650]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[651]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[652]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[653]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[654]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[655]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[656]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[657]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[658]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[659]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[65]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[660]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[661]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[662]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[663]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[664]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[665]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[666]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[667]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[668]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[669]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[66]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[670]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[671]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[672]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[673]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[674]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[675]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[676]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[677]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[678]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[679]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[67]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[680]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[681]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[682]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[683]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[684]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[685]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[686]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[687]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[688]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[689]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[68]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[690]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[691]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[692]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[693]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[694]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[695]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[696]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[697]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[698]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[699]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[69]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[700]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[701]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[702]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[703]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[704]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[705]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[706]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[707]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[708]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[709]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[70]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[710]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[711]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[712]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[713]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[714]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[715]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[716]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[717]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[718]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[719]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[71]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[720]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[721]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[722]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[723]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[724]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[725]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[726]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[727]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[728]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[729]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[72]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[730]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[731]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[732]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[733]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[734]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[735]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[736]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[737]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[738]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[739]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[73]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[740]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[741]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[742]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[743]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[744]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[745]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[746]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[747]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[748]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[749]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[74]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[750]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[751]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[752]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[753]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[754]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[755]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[756]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[757]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[758]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[759]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[75]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[760]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[761]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[762]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[763]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[764]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[765]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[766]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[767]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[768]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[769]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[76]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[770]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[771]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[772]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[773]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[774]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[775]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[776]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[777]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[778]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[779]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[77]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[780]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[781]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[782]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[783]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[784]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[785]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[786]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[787]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[788]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[789]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[78]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[790]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[791]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[792]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[793]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[794]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[795]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[796]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[797]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[798]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[799]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[79]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[800]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[801]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[802]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[803]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[804]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[805]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[806]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[807]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[808]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[809]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[80]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[810]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[811]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[812]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[813]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[814]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[815]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[816]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[817]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[818]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[819]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[81]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[820]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[821]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[822]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[823]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[824]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[825]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[826]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[827]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[828]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[829]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[82]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[830]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[831]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[832]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[833]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[834]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[835]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[836]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[837]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[838]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[839]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[83]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[840]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[841]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[842]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[843]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[844]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[845]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[846]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[847]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[848]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[849]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[84]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[850]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[851]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[852]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[853]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[854]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[855]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[856]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[857]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[858]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[859]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[85]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[860]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[861]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[862]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[863]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[864]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[865]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[866]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[867]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[868]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[869]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[86]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[870]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[871]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[872]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[873]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[874]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[875]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[876]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[877]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[878]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[879]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[87]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[880]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[881]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[882]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[883]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[884]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[885]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[886]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[887]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[888]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[889]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[88]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[890]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[891]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[892]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[893]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[894]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[895]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[896]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[897]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[898]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[899]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[89]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[900]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[901]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[902]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[903]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[904]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[905]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[906]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[907]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[908]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[909]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[90]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[910]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[911]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[912]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[913]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[914]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[915]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[916]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[917]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[918]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[919]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[91]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[920]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[921]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[922]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[923]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[924]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[925]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[926]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[927]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[928]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[929]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[92]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[930]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[931]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[932]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[933]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[934]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[935]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[936]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[937]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[938]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[939]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[93]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[940]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[941]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[942]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[943]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[944]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[945]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[946]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[947]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[948]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[949]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[94]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[950]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[951]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[952]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[953]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[954]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[955]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[956]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[957]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[958]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[959]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[95]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[960]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[961]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[962]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[963]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[964]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[965]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[966]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[967]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[968]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[969]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[96]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[970]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[971]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[972]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[973]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[974]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[975]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[976]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[977]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[978]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[979]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[97]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[980]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[981]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[982]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[983]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[984]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[985]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[986]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[987]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[988]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[989]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[98]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[990]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[991]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[992]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[993]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[994]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[995]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[996]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[997]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[998]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[999]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[99]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 21.stp[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль (66)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль — обрезан 1600 (22)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
